<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo-F410R8-64k.ewp</path>
  </project>
  <batchBuild />
</workspace>
